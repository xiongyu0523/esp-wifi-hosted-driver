<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\netxduo\netxduo.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\sample_azure_iot_embedded_sdk\sample_azure_iot_embedded_sdk.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\stm32l4xx_lib\stm32l4xx_lib.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\threadx\threadx.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>build_all</name>
            <member>
                <project>threadx</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>netxduo</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>stm32l4xx_lib</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>sample_netx_duo_ping</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>sample_threadx</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>sample_azure_iot_embedded_sdk</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>sample_azure_iot_embedded_sdk_pnp</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>sample_pnp_temperature_controller</project>
                <configuration>Debug</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
