# IAR project sample_azure_iot_embedded_sdk.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L4S5VI ST STM32L4S5VI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L4S5xx; USE_HAL_DRIVER; WIFI_SSID=""; WIFI_PASSWORD=""; WIFI_SECURITY_TYPE=WIFI_AUTH_WPA2_PSK
  ICCARM.CCIncludePath2: ..\threadx\common\inc; ..\threadx\ports\cortex_m4\iar\inc; ..\netxduo\common\inc; ..\netxduo\ports\cortex_m4\iar\inc; ..\netxduo\nx_secure\ports; ..\netxduo\crypto_libraries\inc; ..\netxduo\addons\cloud; ..\netxduo\addons\dns; ..\netxduo\addons\mqtt; ..\netxduo\addons\sntp; ..\netxduo\addons\dhcp; ..\netxduo\nx_secure\inc; ..\netxduo\nx_secure\ports; ..\stm32l4xx_lib\; ..\stm32l4xx_lib\CMSIS\Include; ..\stm32l4xx_lib\CMSIS\Device\ST\STM32L4xx\Include; ..\sample_azure_iot_embedded_sdk; ..\common_hardware_code; ..\common_hardware_code\esp-hosted\common\include; ..\common_hardware_code\esp-hosted\common\protobuf-c; ..\common_hardware_code\esp-hosted\host\host_common\include; ..\common_hardware_code\esp-hosted\host\stm32\common; ..\common_hardware_code\esp-hosted\host\stm32\app; ..\common_hardware_code\esp-hosted\host\stm32\app\control; ..\common_hardware_code\esp-hosted\host\stm32\app\data; ..\common_hardware_code\esp-hosted\host\stm32\driver\netif; ..\common_hardware_code\esp-hosted\host\stm32\driver\network; ..\common_hardware_code\esp-hosted\host\stm32\driver\serial; ..\common_hardware_code\esp-hosted\host\stm32\driver\spi; ..\netxduo\addons\azure_iot\azure-sdk-for-c\sdk\inc; ..\netxduo\addons\azure_iot\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: sample.bin
  ILINK.IlinkOutputFile: sample.out
  ILINK.IlinkIcfFile: ..\common_hardware_code\stm32l4s5xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F746NG ST STM32F746NG
  General.CoreVariant: 41
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; STM32F746xx; DISABLE_GUIX; TX_ENABLE_EXECUTION_CHANGE_NOTIFY; ENDPOINT=$PIPELINE_DPS_ENDPOINT$; ID_SCOPE=$PIPELINE_ID_SCOPE$; REGISTRATION_ID=$PIPELINE_REGISTRATION_ID$; HOST_NAME=$PIPELINE_HOST_NAME$; DEVICE_ID=$PIPELINE_DEVICE_ID$; DEVICE_SYMMETRIC_KEY=$PIPELINE_DEVICE_SYMMETRIC_KEY$; DEVICE_CERT=$PIPELINE_DEVICE_CERTIFICATE$; DEVICE_PRIVATE_KEY=$PIPELINE_DEVICE_PRIVATE_KEY$; USE_DEVICE_CERTIFICATE=$PIPELINE_USE_DEVICE_CERTIFICATE$; $PIPELINE_DISABLE_DPS_SAMPLE$; $PIPELINE_DISABLE_TELEMETRY_SAMPLE$; $PIPELINE_DISABLE_C2D_SAMPLE$
  ICCARM.CCIncludePath2: ..\tx; ..\nxd\; ..\nx_secure\; azure-sdk-for-c\sdk\core\core\inc; azure-sdk-for-c\sdk\core\core\internal; azure-sdk-for-c\sdk\iot\core\inc; azure-sdk-for-c\sdk\iot\hub\inc; azure-sdk-for-c\sdk\iot\provisioning\inc; azure-sdk-for-c\sdk\platform\noplatform\inc; ..\stm32f7xx_library; ..\azure_embedded_c_sdk; ..\azure_embedded_c_sdk\azure-sdk-for-c\sdk\iot\hub\inc; ..\azure_embedded_c_sdk\azure-sdk-for-c\sdk\core\core\inc; ..\azure_embedded_c_sdk\azure-sdk-for-c\sdk\iot\core\inc; ..\azure_embedded_c_sdk\azure-sdk-for-c\sdk\iot\provisioning\inc
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: ..\common_hardware_code\stm32f746xx_ITCM_flash.icf
  group Common Source
    ../common_hardware_code/: board_setup.c startup_stm32l4s5xx.s tx_initialize_low_level.s wifi.c wifi.h
  group Common Source/esp-hosted/common
    ../common_hardware_code/esp-hosted/common/: esp_hosted_config.pb-c.c
  group Common Source/esp-hosted/common/include
    ../common_hardware_code/esp-hosted/common/include/: adapter.h esp_hosted_config.pb-c.h
  group Common Source/esp-hosted/common/protobuf-c/protobuf-c
    ../common_hardware_code/esp-hosted/common/protobuf-c/protobuf-c/: protobuf-c.c protobuf-c.h
  group Common Source/esp-hosted/host/host_common
    ../common_hardware_code/esp-hosted/host/host_common/: commands.c transport_pserial.c
  group Common Source/esp-hosted/host/host_common/include
    ../common_hardware_code/esp-hosted/host/host_common/include/: commands.h platform_wrapper.h transport_pserial.h
  group Common Source/esp-hosted/host/stm32/app
    ../common_hardware_code/esp-hosted/host/stm32/app/: app_main_api.c app_main_api.h
  group Common Source/esp-hosted/host/stm32/app/control
    ../common_hardware_code/esp-hosted/host/stm32/app/control/: control.c control.h platform_wrapper.c
  group Common Source/esp-hosted/host/stm32/app/data
    ../common_hardware_code/esp-hosted/host/stm32/app/data/: arp_server_stub.c arp_server_stub.h
  group Common Source/esp-hosted/host/stm32/common
    ../common_hardware_code/esp-hosted/host/stm32/common/: common.c common.h trace.h util.c util.h
  group Common Source/esp-hosted/host/stm32/driver/netif
    ../common_hardware_code/esp-hosted/host/stm32/driver/netif/: netdev_if.h
  group Common Source/esp-hosted/host/stm32/driver/network
    ../common_hardware_code/esp-hosted/host/stm32/driver/network/: netdev_api.c netdev_api.h netdev_stub.c netdev_stub.h
  group Common Source/esp-hosted/host/stm32/driver/serial
    ../common_hardware_code/esp-hosted/host/stm32/driver/serial/: serial_drv.h serial_if.c serial_if.h
  group Common Source/esp-hosted/host/stm32/driver/spi
    ../common_hardware_code/esp-hosted/host/stm32/driver/spi/: spi_drv.c spi_drv.h
  group Lib
    ../netxduo/Debug/Exe/: netxduo.a
    ../stm32l4xx_lib/Debug/Exe/: stm32l4xx_lib.a
    ../threadx/Debug/Exe/: threadx.a
  group Sample
    ./: main.c nx_azure_iot_cert.c nx_azure_iot_ciphersuites.c nx_driver_esp_hosted.c sample_azure_iot_embedded_sdk.c sample_config.h sample_device_identity.c sample_network.c
